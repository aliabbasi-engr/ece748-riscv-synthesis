* Circuit, read from the shapes
.subckt SRAM_32x64_1rw_wordline_driver_array en gnd in_0 in_1 in_10 in_11 in_12 in_13 in_14 in_15 in_2 in_3 in_4 in_5 in_6 in_7 in_8 in_9 vdd wl_0 wl_1 wl_10 wl_11 wl_12 wl_13 wl_14 wl_15 wl_2 wl_3 wl_4 wl_5 wl_6 wl_7 wl_8 wl_9
M1 SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_0 gnd gnd nfet w=0.18u l=0.05u
M2 SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_1 gnd gnd nfet w=0.18u l=0.05u
M3 SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_2 gnd gnd nfet w=0.18u l=0.05u
M4 SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_3 gnd gnd nfet w=0.18u l=0.05u
M5 SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_4 gnd gnd nfet w=0.18u l=0.05u
M6 SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_5 gnd gnd nfet w=0.18u l=0.05u
M7 SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_6 gnd gnd nfet w=0.18u l=0.05u
M8 SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_7 gnd gnd nfet w=0.18u l=0.05u
M9 SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_8 gnd gnd nfet w=0.18u l=0.05u
M10 SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_9 gnd gnd nfet w=0.18u l=0.05u
M11 SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_10 gnd gnd nfet w=0.18u l=0.05u
M12 SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_11 gnd gnd nfet w=0.18u l=0.05u
M13 SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_12 gnd gnd nfet w=0.18u l=0.05u
M14 SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_13 gnd gnd nfet w=0.18u l=0.05u
M15 SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_14 gnd gnd nfet w=0.18u l=0.05u
M16 SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D in_15 gnd gnd nfet w=0.18u l=0.05u
M17 SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M18 SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M19 SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M20 SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M21 SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M22 SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M23 SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M24 SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M25 SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M26 SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M27 SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M28 SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M29 SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M30 SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M31 SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M32 SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pinv_0_1/A en SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pnand2_0/SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive_2/D gnd nfet w=0.18u l=0.05u
M33 wl_0 SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M34 wl_1 SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M35 wl_2 SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M36 wl_3 SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M37 wl_4 SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M38 wl_5 SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M39 wl_6 SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M40 wl_7 SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M41 wl_8 SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M42 wl_9 SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M43 wl_10 SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M44 wl_11 SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M45 wl_12 SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M46 wl_13 SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M47 wl_14 SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M48 wl_15 SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pinv_0_1/A gnd gnd nfet w=0.12u l=0.05u m=24
M49 SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pinv_0_1/A in_0 vdd vdd pfet w=0.27u l=0.05u
M50 SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pinv_0_1/A in_1 vdd vdd pfet w=0.27u l=0.05u
M51 SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pinv_0_1/A in_2 vdd vdd pfet w=0.27u l=0.05u
M52 SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pinv_0_1/A in_3 vdd vdd pfet w=0.27u l=0.05u
M53 SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pinv_0_1/A in_4 vdd vdd pfet w=0.27u l=0.05u
M54 SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pinv_0_1/A in_5 vdd vdd pfet w=0.27u l=0.05u
M55 SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pinv_0_1/A in_6 vdd vdd pfet w=0.27u l=0.05u
M56 SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pinv_0_1/A in_7 vdd vdd pfet w=0.27u l=0.05u
M57 SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pinv_0_1/A in_8 vdd vdd pfet w=0.27u l=0.05u
M58 SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pinv_0_1/A in_9 vdd vdd pfet w=0.27u l=0.05u
M59 SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pinv_0_1/A in_10 vdd vdd pfet w=0.27u l=0.05u
M60 SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pinv_0_1/A in_11 vdd vdd pfet w=0.27u l=0.05u
M61 SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pinv_0_1/A in_12 vdd vdd pfet w=0.27u l=0.05u
M62 SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pinv_0_1/A in_13 vdd vdd pfet w=0.27u l=0.05u
M63 SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pinv_0_1/A in_14 vdd vdd pfet w=0.27u l=0.05u
M64 SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pinv_0_1/A in_15 vdd vdd pfet w=0.27u l=0.05u
M65 vdd en SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M66 vdd en SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M67 vdd en SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M68 vdd en SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M69 vdd en SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M70 vdd en SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M71 vdd en SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M72 vdd en SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M73 vdd en SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M74 vdd en SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M75 vdd en SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M76 vdd en SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M77 vdd en SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M78 vdd en SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M79 vdd en SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M80 vdd en SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pinv_0_1/A vdd pfet w=0.27u l=0.05u
M81 wl_0 SRAM_32x64_1rw_wordline_driver_0/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M82 wl_1 SRAM_32x64_1rw_wordline_driver_1/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M83 wl_2 SRAM_32x64_1rw_wordline_driver_2/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M84 wl_3 SRAM_32x64_1rw_wordline_driver_3/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M85 wl_4 SRAM_32x64_1rw_wordline_driver_4/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M86 wl_5 SRAM_32x64_1rw_wordline_driver_5/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M87 wl_6 SRAM_32x64_1rw_wordline_driver_6/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M88 wl_7 SRAM_32x64_1rw_wordline_driver_7/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M89 wl_8 SRAM_32x64_1rw_wordline_driver_8/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M90 wl_9 SRAM_32x64_1rw_wordline_driver_9/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M91 wl_10 SRAM_32x64_1rw_wordline_driver_10/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M92 wl_11 SRAM_32x64_1rw_wordline_driver_11/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M93 wl_12 SRAM_32x64_1rw_wordline_driver_12/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M94 wl_13 SRAM_32x64_1rw_wordline_driver_13/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M95 wl_14 SRAM_32x64_1rw_wordline_driver_14/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
M96 wl_15 SRAM_32x64_1rw_wordline_driver_15/SRAM_32x64_1rw_pinv_0_1/A vdd vdd pfet w=0.36u l=0.05u m=24
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=5e-10)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
active = (1, 0)
pwell = (2, 0)
nwell = (3, 0)
nimplant = (4, 0)
pimplant = (5, 0)
vtg = (6, 0)
poly = (9, 0)
contact = (10, 0)
metal1 = (11, 0)
via1 = (12, 0)
metal2 = (13, 0)
via2 = (14, 0)
metal3 = (15, 0)
via3 = (16, 0)
metal4 = (17, 0)
boundary2 = (239, 0)

sram_32x64_1rw_contact_1 = lib.new_cell('SRAM_32x64_1rw_contact_11')
R(sram_32x64_1rw_contact_1, active, [(0,0.0225,0.09,0.1125)])
R(sram_32x64_1rw_contact_1, nwell, [(-0.055,-0.0325,0.145,0.1675)])
R(sram_32x64_1rw_contact_1, pimplant, [(0,0.0225,0.09,0.1125)])
R(sram_32x64_1rw_contact_1, contact, [(0.0125,0.035,0.0775,0.1)])
R(sram_32x64_1rw_contact_1, metal1, [(0.0125,0,0.0775,0.135)])
R(sram_32x64_1rw_contact_1, boundary2, [(-0.055,-0.0325,0.145,0.1675)])

sram_32x64_1rw_pmos_m1_w = lib.new_cell('SRAM_32x64_1rw_pmos_m1_w0_270_sm1_dm1')
R(sram_32x64_1rw_pmos_m1_w, active, [(0,0,0.305,0.27)])
R(sram_32x64_1rw_pmos_m1_w, nwell, [(-0.08,-0.08,0.385,0.35)])
R(sram_32x64_1rw_pmos_m1_w, pimplant, [(0,0,0.305,0.27)])
R(sram_32x64_1rw_pmos_m1_w, vtg, [(-0.08,-0.08,0.385,0.35)])
R(sram_32x64_1rw_pmos_m1_w, poly, [(0.1275,-0.055,0.1775,0.325), (0.1275,-0.055,0.1775,0.325)])
R(sram_32x64_1rw_pmos_m1_w, metal1, [(0.0125,0.0675,0.0775,0.2025), (0.2275,0.0675,0.2925,0.2025)])
R(sram_32x64_1rw_pmos_m1_w, boundary2, [(-0.08,-0.08,0.385,0.35)])
sram_32x64_1rw_pmos_m1_w.add(gdstk.Reference(sram_32x64_1rw_contact_1, (0,0.0675)))
sram_32x64_1rw_pmos_m1_w.add(gdstk.Reference(sram_32x64_1rw_contact_1, (0.215,0.0675)))
sram_32x64_1rw_pmos_m1_w.add(gdstk.Label('G', (0.1525,0.135), layer=9, texttype=0))
sram_32x64_1rw_pmos_m1_w.add(gdstk.Label('S', (0.045,0.135), layer=11, texttype=0))
sram_32x64_1rw_pmos_m1_w.add(gdstk.Label('D', (0.26,0.135), layer=11, texttype=0))

c_sram_32x64_1rw_contact_1 = lib.new_cell('SRAM_32x64_1rw_contact_10')
R(c_sram_32x64_1rw_contact_1, active, [(0,0.0225,0.09,0.1125)])
R(c_sram_32x64_1rw_contact_1, pwell, [(-0.055,-0.0325,0.145,0.1675)])
R(c_sram_32x64_1rw_contact_1, nimplant, [(0,0.0225,0.09,0.1125)])
R(c_sram_32x64_1rw_contact_1, contact, [(0.0125,0.035,0.0775,0.1)])
R(c_sram_32x64_1rw_contact_1, metal1, [(0.0125,0,0.0775,0.135)])
R(c_sram_32x64_1rw_contact_1, boundary2, [(-0.055,-0.0325,0.145,0.1675)])

sram_32x64_1rw_nmos_m1_w = lib.new_cell('SRAM_32x64_1rw_nmos_m1_w0_180_sm1_dactive')
R(sram_32x64_1rw_nmos_m1_w, active, [(0,0,0.305,0.18), (0.215,0.045,0.305,0.135)])
R(sram_32x64_1rw_nmos_m1_w, pwell, [(-0.08,-0.08,0.385,0.26)])
R(sram_32x64_1rw_nmos_m1_w, nimplant, [(0,0,0.305,0.18)])
R(sram_32x64_1rw_nmos_m1_w, vtg, [(-0.08,-0.08,0.385,0.26)])
R(sram_32x64_1rw_nmos_m1_w, poly, [(0.1275,-0.055,0.1775,0.235), (0.1275,-0.055,0.1775,0.235)])
R(sram_32x64_1rw_nmos_m1_w, metal1, [(0.0125,0.0225,0.0775,0.1575)])
R(sram_32x64_1rw_nmos_m1_w, boundary2, [(-0.08,-0.08,0.385,0.26)])
sram_32x64_1rw_nmos_m1_w.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (0,0.0225)))
sram_32x64_1rw_nmos_m1_w.add(gdstk.Label('G', (0.1525,0.09), layer=9, texttype=0))
sram_32x64_1rw_nmos_m1_w.add(gdstk.Label('S', (0.045,0.09), layer=11, texttype=0))
sram_32x64_1rw_nmos_m1_w.add(gdstk.Label('D', (0.26,0.09), layer=1, texttype=0))

c_sram_32x64_1rw_nmos_m1_w = lib.new_cell('SRAM_32x64_1rw_nmos_m1_w0_180_sactive_dm1')
R(c_sram_32x64_1rw_nmos_m1_w, active, [(0,0,0.305,0.18), (0,0.045,0.09,0.135)])
R(c_sram_32x64_1rw_nmos_m1_w, pwell, [(-0.08,-0.08,0.385,0.26)])
R(c_sram_32x64_1rw_nmos_m1_w, nimplant, [(0,0,0.305,0.18)])
R(c_sram_32x64_1rw_nmos_m1_w, vtg, [(-0.08,-0.08,0.385,0.26)])
R(c_sram_32x64_1rw_nmos_m1_w, poly, [(0.1275,-0.055,0.1775,0.235), (0.1275,-0.055,0.1775,0.235)])
R(c_sram_32x64_1rw_nmos_m1_w, metal1, [(0.2275,0.0225,0.2925,0.1575)])
R(c_sram_32x64_1rw_nmos_m1_w, boundary2, [(-0.08,-0.08,0.385,0.26)])
c_sram_32x64_1rw_nmos_m1_w.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (0.215,0.0225)))
c_sram_32x64_1rw_nmos_m1_w.add(gdstk.Label('G', (0.1525,0.09), layer=9, texttype=0))
c_sram_32x64_1rw_nmos_m1_w.add(gdstk.Label('S', (0.045,0.09), layer=1, texttype=0))
c_sram_32x64_1rw_nmos_m1_w.add(gdstk.Label('D', (0.26,0.09), layer=11, texttype=0))

c_sram_32x64_1rw_contact_1_ = lib.new_cell('SRAM_32x64_1rw_contact_12')
R(c_sram_32x64_1rw_contact_1_, active, [(0,0.0225,0.09,0.1125)])
R(c_sram_32x64_1rw_contact_1_, nwell, [(-0.055,-0.0325,0.145,0.1675)])
R(c_sram_32x64_1rw_contact_1_, nimplant, [(0,0.0225,0.09,0.1125)])
R(c_sram_32x64_1rw_contact_1_, contact, [(0.0125,0.035,0.0775,0.1)])
R(c_sram_32x64_1rw_contact_1_, metal1, [(0.0125,0,0.0775,0.135)])
R(c_sram_32x64_1rw_contact_1_, boundary2, [(-0.055,-0.0325,0.145,0.1675)])

c_sram_32x64_1rw_contact_1__ = lib.new_cell('SRAM_32x64_1rw_contact_13')
R(c_sram_32x64_1rw_contact_1__, active, [(0,0.0225,0.09,0.1125)])
R(c_sram_32x64_1rw_contact_1__, pwell, [(-0.055,-0.0325,0.145,0.1675)])
R(c_sram_32x64_1rw_contact_1__, pimplant, [(0,0.0225,0.09,0.1125)])
R(c_sram_32x64_1rw_contact_1__, contact, [(0.0125,0.035,0.0775,0.1)])
R(c_sram_32x64_1rw_contact_1__, metal1, [(0.0125,0,0.0775,0.135)])
R(c_sram_32x64_1rw_contact_1__, boundary2, [(-0.055,-0.0325,0.145,0.1675)])

c_sram_32x64_1rw_contact_1___ = lib.new_cell('SRAM_32x64_1rw_contact_14')
R(c_sram_32x64_1rw_contact_1___, poly, [(0.03,0,0.105,0.075)])
R(c_sram_32x64_1rw_contact_1___, contact, [(0.035,0.005,0.1,0.07)])
R(c_sram_32x64_1rw_contact_1___, metal1, [(0,0.005,0.135,0.07)])
R(c_sram_32x64_1rw_contact_1___, boundary2, [(0,0,0.135,0.075)])

sram_32x64_1rw_pnand2 = lib.new_cell('SRAM_32x64_1rw_pnand2')
R(sram_32x64_1rw_pnand2, pwell, [(-0.055,-0.0325,0.9575,0.655)])
R(sram_32x64_1rw_pnand2, nwell, [(-0.055,0.655,0.9575,1.4)])
R(sram_32x64_1rw_pnand2, vtg, [(-0.055,-0.0325,0.9575,0.655), (-0.055,0.655,0.9575,1.4)])
R(sram_32x64_1rw_pnand2, poly, [(0.2075,0.36,0.2575,0.915), (0.4225,0.36,0.4725,0.915), (0.2075,0.39,0.2325,0.465), (0.4225,0.67,0.4475,0.745)])
R(sram_32x64_1rw_pnand2, metal1, [(0,-0.0325,0.9025,0.0325), (0.0925,-0.0325,0.1575,0.1475), (0.6925,0,0.7575,0.17), (0.5225,0.2825,0.5875,0.4125), (0.5225,0.38,0.5875,0.445), (0.555,0.38,0.685,0.445), (0.6525,0.38,0.7175,0.445), (0.165,0.395,0.3,0.46), (0.6525,0.4125,0.7175,0.94), (0.38,0.675,0.515,0.74), (0.3075,0.9075,0.3725,0.9725), (0.34,0.9075,0.685,0.9725), (0.6525,0.9075,0.7175,0.9725), (0.3075,0.94,0.3725,1.0375), (0.0925,1.0375,0.1575,1.3975), (0.5225,1.0375,0.5875,1.3975), (0.6925,1.195,0.7575,1.365), (0,1.3325,0.9025,1.3975)])
R(sram_32x64_1rw_pnand2, boundary2, [(0,0,0.9025,1.365), (0,0,0.9025,1.365)])
sram_32x64_1rw_pnand2.add(gdstk.Reference(sram_32x64_1rw_pmos_m1_w, (0.08,0.97)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(sram_32x64_1rw_pmos_m1_w, (0.295,0.97)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(sram_32x64_1rw_nmos_m1_w, (0.08,0.125)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(c_sram_32x64_1rw_nmos_m1_w, (0.295,0.125)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_, (0.68,1.1275)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(c_sram_32x64_1rw_contact_1__, (0.68,0.1025)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(c_sram_32x64_1rw_contact_1___, (0.165,0.39)))
sram_32x64_1rw_pnand2.add(gdstk.Reference(c_sram_32x64_1rw_contact_1___, (0.38,0.67)))
sram_32x64_1rw_pnand2.add(gdstk.Label('Z', (0.685,0.94), layer=11, texttype=0))
sram_32x64_1rw_pnand2.add(gdstk.Label('gnd', (0.451,0), layer=11, texttype=0))
sram_32x64_1rw_pnand2.add(gdstk.Label('vdd', (0.451,1.365), layer=11, texttype=0))
sram_32x64_1rw_pnand2.add(gdstk.Label('A', (0.2325,0.4275), layer=11, texttype=0))
sram_32x64_1rw_pnand2.add(gdstk.Label('B', (0.4475,0.7075), layer=11, texttype=0))

sram_32x64_1rw_pmos_m24_ = lib.new_cell('SRAM_32x64_1rw_pmos_m24_w0_360_sm1_dm1_da_p')
R(sram_32x64_1rw_pmos_m24_, active, [(0,0,6.63,0.36)])
R(sram_32x64_1rw_pmos_m24_, nwell, [(-0.08,-0.08,6.71,0.44)])
R(sram_32x64_1rw_pmos_m24_, pimplant, [(0,0,6.63,0.36)])
R(sram_32x64_1rw_pmos_m24_, vtg, [(-0.08,-0.08,6.71,0.44)])
A(sram_32x64_1rw_pmos_m24_, poly, 0.1275, -0.055, 0.05, 0.47, 24, 1, 0.275, 0)
R(sram_32x64_1rw_pmos_m24_, poly, [(0.1275,-0.105,6.5025,-0.055)])
A(sram_32x64_1rw_pmos_m24_, metal1, 0.2575, 0.015, 0.065, 0.165, 12, 1, 0.55, 0)
A(sram_32x64_1rw_pmos_m24_, metal1, 0.5325, 0.1125, 0.065, 0.135, 11, 1, 0.55, 0)
R(sram_32x64_1rw_pmos_m24_, metal1, [(0.2575,-0.0175,6.3725,0.0475), (0.0125,0.1125,0.0775,0.2475), (6.5525,0.1125,6.6175,0.2475)])
R(sram_32x64_1rw_pmos_m24_, boundary2, [(-0.08,-0.105,6.71,0.44)])
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (0,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (0.245,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (0.52,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (0.795,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (1.07,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (1.345,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (1.62,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (1.895,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (2.17,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (2.445,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (2.72,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (2.995,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (3.27,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (3.545,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (3.82,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (4.095,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (4.37,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (4.645,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (4.92,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (5.195,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (5.47,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (5.745,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (6.02,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (6.295,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Reference(sram_32x64_1rw_contact_1, (6.54,0.1125)))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('G', (3.315,-0.08), layer=9, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (1.665,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (3.315,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (4.965,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (2.215,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (3.865,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (5.515,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (6.585,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (1.115,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (4.415,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (0.045,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (2.765,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (0.565,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('S', (6.065,0.18), layer=11, texttype=0))
sram_32x64_1rw_pmos_m24_.add(gdstk.Label('D', (3.315,0.015), layer=11, texttype=0))

sram_32x64_1rw_nmos_m24_ = lib.new_cell('SRAM_32x64_1rw_nmos_m24_w0_120_sm1_dm1_da_p')
R(sram_32x64_1rw_nmos_m24_, active, [(0,0,6.63,0.12)])
R(sram_32x64_1rw_nmos_m24_, pwell, [(-0.08,-0.08,6.71,0.2)])
R(sram_32x64_1rw_nmos_m24_, nimplant, [(0,0,6.63,0.12)])
R(sram_32x64_1rw_nmos_m24_, vtg, [(-0.08,-0.08,6.71,0.2)])
A(sram_32x64_1rw_nmos_m24_, poly, 0.1275, -0.055, 0.05, 0.23, 24, 1, 0.275, 0)
R(sram_32x64_1rw_nmos_m24_, poly, [(0.1275,0.175,6.5025,0.225)])
A(sram_32x64_1rw_nmos_m24_, metal1, 0.5325, -0.0075, 0.065, 0.135, 11, 1, 0.55, 0)
A(sram_32x64_1rw_nmos_m24_, metal1, 0.2575, 0.06, 0.065, 0.165, 12, 1, 0.55, 0)
R(sram_32x64_1rw_nmos_m24_, metal1, [(0.0125,-0.0075,0.0775,0.1275), (6.5525,-0.0075,6.6175,0.1275), (0.2575,0.1925,6.3725,0.2575)])
R(sram_32x64_1rw_nmos_m24_, boundary2, [(-0.08,-0.08,6.71,0.2575)])
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (0,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (0.245,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (0.52,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (0.795,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (1.07,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (1.345,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (1.62,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (1.895,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (2.17,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (2.445,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (2.72,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (2.995,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (3.27,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (3.545,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (3.82,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (4.095,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (4.37,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (4.645,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (4.92,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (5.195,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (5.47,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (5.745,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (6.02,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (6.295,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1, (6.54,-0.0075)))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('G', (3.315,0.2), layer=9, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (1.115,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (2.765,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (5.515,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (4.965,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (0.045,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (0.565,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (3.315,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (6.065,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (2.215,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (4.415,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (3.865,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (6.585,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('S', (1.665,0.06), layer=11, texttype=0))
sram_32x64_1rw_nmos_m24_.add(gdstk.Label('D', (3.315,0.225), layer=11, texttype=0))

sram_32x64_1rw_pinv_0 = lib.new_cell('SRAM_32x64_1rw_pinv_0')
R(sram_32x64_1rw_pinv_0, pwell, [(-0.055,-0.0325,7.0675,0.655)])
R(sram_32x64_1rw_pinv_0, nwell, [(-0.055,0.655,7.0675,1.4)])
R(sram_32x64_1rw_pinv_0, vtg, [(-0.055,-0.0325,7.0675,0.655), (-0.055,0.655,7.0675,1.4)])
R(sram_32x64_1rw_pinv_0, poly, [(0.2075,0.35,0.2575,0.775), (0.14,0.585,0.2075,0.66)])
A(sram_32x64_1rw_pinv_0, metal1, 0.6125, -0.0325, 0.065, 0.15, 11, 1, 0.55, 0)
A(sram_32x64_1rw_pinv_0, metal1, 0.6125, 0.9925, 0.065, 0.405, 11, 1, 0.55, 0)
R(sram_32x64_1rw_pinv_0, metal1, [(0,-0.0325,7.0125,0.0325), (0.0925,-0.0325,0.1575,0.1175), (6.6325,-0.0325,6.6975,0.1175), (6.8025,0,6.8675,0.17), (3.3625,0.3175,3.4275,0.9275), (0.0725,0.59,0.2075,0.655), (3.395,0.59,3.46,0.655), (0.0925,0.9925,0.1575,1.3975), (6.6325,0.9925,6.6975,1.3975), (6.8025,1.195,6.8675,1.365), (0,1.3325,7.0125,1.3975)])
R(sram_32x64_1rw_pinv_0, boundary2, [(0,0,7.0125,1.365), (0,0,7.0125,1.365)])
sram_32x64_1rw_pinv_0.add(gdstk.Reference(sram_32x64_1rw_pmos_m24_, (0.08,0.88)))
sram_32x64_1rw_pinv_0.add(gdstk.Reference(sram_32x64_1rw_nmos_m24_, (0.08,0.125)))
sram_32x64_1rw_pinv_0.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_, (6.79,1.1275)))
sram_32x64_1rw_pinv_0.add(gdstk.Reference(c_sram_32x64_1rw_contact_1__, (6.79,0.1025)))
sram_32x64_1rw_pinv_0.add(gdstk.Reference(c_sram_32x64_1rw_contact_1___, (0.0725,0.585)))
sram_32x64_1rw_pinv_0.add(gdstk.Label('A', (0.14,0.6225), layer=11, texttype=0))
sram_32x64_1rw_pinv_0.add(gdstk.Label('Z', (3.4275,0.6225), layer=11, texttype=0))
sram_32x64_1rw_pinv_0.add(gdstk.Label('gnd', (3.506,0), layer=11, texttype=0))
sram_32x64_1rw_pinv_0.add(gdstk.Label('vdd', (3.506,1.365), layer=11, texttype=0))

sram_32x64_1rw_wordline_ = lib.new_cell('SRAM_32x64_1rw_wordline_driver')
R(sram_32x64_1rw_wordline_, metal1, [(0,-0.0325,7.915,0.0325), (0.165,0.395,0.3,0.46), (0.6525,0.59,0.7175,0.655), (0.685,0.59,1.0425,0.655), (4.2975,0.59,4.3625,0.655), (0.6525,0.6225,0.7175,0.94), (0.38,0.675,0.515,0.74), (0,1.3325,7.915,1.3975)])
R(sram_32x64_1rw_wordline_, boundary2, [(0,0,7.915,1.365)])
sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_pnand2, (0,0)))
sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_pinv_0, (0.9025,0)))
sram_32x64_1rw_wordline_.add(gdstk.Label('Z', (4.33,0.6225), layer=11, texttype=0))
sram_32x64_1rw_wordline_.add(gdstk.Label('A', (0.2325,0.4275), layer=11, texttype=0))
sram_32x64_1rw_wordline_.add(gdstk.Label('B', (0.4475,0.7075), layer=11, texttype=0))
sram_32x64_1rw_wordline_.add(gdstk.Label('gnd', (3.9575,0), layer=11, texttype=0))
sram_32x64_1rw_wordline_.add(gdstk.Label('vdd', (3.9575,1.365), layer=11, texttype=0))

c_sram_32x64_1rw_contact_1____ = lib.new_cell('SRAM_32x64_1rw_contact_17')
R(c_sram_32x64_1rw_contact_1____, metal1, [(0,0.035,0.135,0.1)])
R(c_sram_32x64_1rw_contact_1____, via1, [(0.035,0.035,0.1,0.1)])
R(c_sram_32x64_1rw_contact_1____, metal2, [(0.0325,0,0.1025,0.135)])
R(c_sram_32x64_1rw_contact_1____, boundary2, [(0,0,0.135,0.135)])

c_sram_32x64_1rw_contact_1_____ = lib.new_cell('SRAM_32x64_1rw_contact_18')
R(c_sram_32x64_1rw_contact_1_____, metal2, [(0.0325,0,0.1025,0.135)])
R(c_sram_32x64_1rw_contact_1_____, via2, [(0.035,0.035,0.1,0.1)])
R(c_sram_32x64_1rw_contact_1_____, metal3, [(0,0.0325,0.135,0.1025)])
R(c_sram_32x64_1rw_contact_1_____, boundary2, [(0,0,0.135,0.135)])

sram_32x64_1rw_contact_2 = lib.new_cell('SRAM_32x64_1rw_contact_21')
R(sram_32x64_1rw_contact_2, metal3, [(0,0.035,0.14,0.105)])
R(sram_32x64_1rw_contact_2, via3, [(0.035,0.035,0.105,0.105)])
R(sram_32x64_1rw_contact_2, metal4, [(0,0,0.14,0.14)])
R(sram_32x64_1rw_contact_2, boundary2, [(0,0,0.14,0.14)])

c_sram_32x64_1rw_wordline_ = lib.new_cell('SRAM_32x64_1rw_wordline_driver_array')
R(c_sram_32x64_1rw_wordline_, metal1, [(0.725,0.395,0.86,0.46), (4.8575,0.59,4.9225,0.655), (4.8575,2.075,4.9225,2.14), (0.725,2.27,0.86,2.335), (0.725,3.125,0.86,3.19), (4.8575,3.32,4.9225,3.385), (4.8575,4.805,4.9225,4.87), (0.725,5,0.86,5.065), (0.725,5.855,0.86,5.92), (4.8575,6.05,4.9225,6.115), (4.8575,7.535,4.9225,7.6), (0.725,7.73,0.86,7.795), (0.725,8.585,0.86,8.65), (4.8575,8.78,4.9225,8.845), (4.8575,10.265,4.9225,10.33), (0.725,10.46,0.86,10.525), (0.725,11.315,0.86,11.38), (4.8575,11.51,4.9225,11.575), (4.8575,12.995,4.9225,13.06), (0.725,13.19,0.86,13.255), (0.725,14.045,0.86,14.11), (4.8575,14.24,4.9225,14.305), (4.8575,15.725,4.9225,15.79), (0.725,15.92,0.86,15.985), (0.725,16.775,0.86,16.84), (4.8575,16.97,4.9225,17.035), (4.8575,18.455,4.9225,18.52), (0.725,18.65,0.86,18.715), (0.725,19.505,0.86,19.57), (4.8575,19.7,4.9225,19.765), (4.8575,21.185,4.9225,21.25), (0.725,21.38,0.86,21.445)])
R(c_sram_32x64_1rw_wordline_, metal2, [(0.9725,0,1.0425,21.84)])
R(c_sram_32x64_1rw_wordline_, metal4, [(0.49,-0.1025,0.63,21.9425), (8.405,-0.07,8.545,21.91)])
R(c_sram_32x64_1rw_wordline_, boundary2, [(0,0,8.98,21.84)])
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,0)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,2.73), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,2.73)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,5.46), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,5.46)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,8.19), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,8.19)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,10.92), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,10.92)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,13.65), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,13.65)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,16.38), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,16.38)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,19.11), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,19.11)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_wordline_, (0.56,21.84), x_reflection=True))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,0.64)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,1.955)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,3.37)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,4.685)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,6.1)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,7.415)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,8.83)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,10.145)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,11.56)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,12.875)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,14.29)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,15.605)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,17.02)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,18.335)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,19.75)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.94,21.065)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,1.2975)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,1.2975)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,1.295)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,1.2975)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,1.2975)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,1.295)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,4.0275)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,4.0275)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,4.025)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,4.0275)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,4.0275)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,4.025)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,6.7575)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,6.7575)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,6.755)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,6.7575)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,6.7575)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,6.755)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,9.4875)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,9.4875)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,9.485)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,9.4875)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,9.4875)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,9.485)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,12.2175)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,12.2175)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,12.215)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,12.2175)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,12.2175)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,12.215)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,14.9475)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,14.9475)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,14.945)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,14.9475)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,14.9475)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,14.945)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,17.6775)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,17.6775)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,17.675)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,17.6775)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,17.6775)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,17.675)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,20.4075)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,20.4075)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,20.405)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (8.4075,20.4075)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (8.4075,20.4075)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (8.405,20.405)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,-0.0675)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,-0.0675)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,-0.07)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,2.6625)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,2.6625)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,2.66)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,2.6625)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,2.6625)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,2.66)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,5.3925)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,5.3925)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,5.39)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,5.3925)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,5.3925)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,5.39)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,8.1225)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,8.1225)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,8.12)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,8.1225)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,8.1225)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,8.12)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,10.8525)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,10.8525)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,10.85)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,10.8525)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,10.8525)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,10.85)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,13.5825)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,13.5825)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,13.58)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,13.5825)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,13.5825)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,13.58)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,16.3125)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,16.3125)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,16.31)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,16.3125)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,16.3125)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,16.31)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,19.0425)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,19.0425)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,19.04)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,19.0425)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,19.0425)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,19.04)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1____, (0.4925,21.7725)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(c_sram_32x64_1rw_contact_1_____, (0.4925,21.7725)))
c_sram_32x64_1rw_wordline_.add(gdstk.Reference(sram_32x64_1rw_contact_2, (0.49,21.77)))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('en', (1.0075,10.92), layer=13, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_0', (0.7925,0.4275), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_0', (4.89,0.6225), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_1', (0.7925,2.3025), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_1', (4.89,2.1075), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_2', (0.7925,3.1575), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_2', (4.89,3.3525), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_3', (0.7925,5.0325), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_3', (4.89,4.8375), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_4', (0.7925,5.8875), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_4', (4.89,6.0825), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_5', (0.7925,7.7625), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_5', (4.89,7.5675), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_6', (0.7925,8.6175), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_6', (4.89,8.8125), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_7', (0.7925,10.4925), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_7', (4.89,10.2975), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_8', (0.7925,11.3475), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_8', (4.89,11.5425), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_9', (0.7925,13.2225), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_9', (4.89,13.0275), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_10', (0.7925,14.0775), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_10', (4.89,14.2725), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_11', (0.7925,15.9525), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_11', (4.89,15.7575), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_12', (0.7925,16.8075), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_12', (4.89,17.0025), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_13', (0.7925,18.6825), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_13', (4.89,18.4875), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_14', (0.7925,19.5375), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_14', (4.89,19.7325), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('in_15', (0.7925,21.4125), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('wl_15', (4.89,21.2175), layer=11, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('vdd', (8.475,10.92), layer=17, texttype=0))
c_sram_32x64_1rw_wordline_.add(gdstk.Label('gnd', (0.56,10.92), layer=17, texttype=0))

lib.write_gds('SRAM_32x64_1rw_wordline_driver_array.gds')
